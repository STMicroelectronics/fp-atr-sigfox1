# IAR project Sigfox_IKS01A3_BLE.ewp, settings and files
configuration Sigfox_IKS01A3_BLE (ARM, debug)
  General.OGChipSelectEditMenu: STM32L073RZ ST STM32L073RZ
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 5
  ICCARM.CCDefines: USE_S2868A1; USE_IKS01A3; USE_BLE; USE_GNSS; USE_HAL_DRIVER; STM32L073xx
  ICCARM.CCIncludePath2: ../Inc; ../../../../../Drivers/STM32L0xx_HAL_Driver/Inc; ../../../../../Drivers/STM32L0xx_HAL_Driver/Inc/Legacy; ../../../../../Drivers/CMSIS/Device/ST/STM32L0xx/Include; ../../../../../Drivers/CMSIS/Include; ../../../../../Middlewares/ST/lib_gnss/LibGNSS/Inc; ../../../../../Middlewares/ST/lib_gnss/LibNMEA/Inc; ../../../../../Drivers/BSP/Components/teseo_liv3f; ../../../../../Drivers/BSP/GNSS1A1; ../../../../../Middlewares/Third_Party/Sigfox/Sigfox_STM32_Library/Inc; ../../../../../Middlewares/Third_Party/Sigfox/Sigfox/Inc; ../../../../../Middlewares/ST/BlueNRG-MS/utils; ../../../../../Middlewares/ST/BlueNRG-MS/includes; ../../../../../Middlewares/ST/BlueNRG-MS/hci/hci_tl_patterns/Basic; ../../../../../Drivers/BSP/Components/lsm6dso; ../../../../../Drivers/BSP/Components/lis2dw12; ../../../../../Drivers/BSP/Components/lis2mdl; ../../../../../Drivers/BSP/Components/hts221; ../../../../../Drivers/BSP/Components/lps22hh; ../../../../../Drivers/BSP/Components/stts751; ../../../../../Drivers/BSP/IKS01A3; ../../../../../Drivers/BSP/Components/Common; ../../../../../Drivers/BSP/S2868A1; ../../../../../Drivers/BSP/Components/S2LP; ../../../../../Drivers/BSP/Components/S2LP/S2LP_Library/inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Sigfox_IKS01A3_BLE.hex
  ILINK.IlinkOutputFile: Sigfox_IKS01A3_BLE.out
  ILINK.IlinkIcfFile: stm32l073xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32l073xx.s
  group Application/User
    ../Src/: main.c app_mems-library.c app_x_cube_sfxs2lp1.c sensor_service.c sensors.c app_bluenrg_ms.c app_mems_int_pin_interface.c app_fp-atr-sigfox1.c hci_tl_interface.c stm32_bus_ex.c gnss_lib_config.c sfx_config.c s2lp_management.c stm32l0xx_nucleo_bus.c stm32l0xx_nucleo.c stm32l0xx_it.c stm32l0xx_hal_msp.c
  group Drivers/BSP/Components
    ../../../../../Drivers/BSP/Components/teseo_liv3f/: teseo_liv3f.c teseo_liv3f_i2c.c teseo_liv3f_queue.c teseo_liv3f_uart.c
    ../../../../../Drivers/BSP/Components/lsm6dso/: lsm6dso_reg.c lsm6dso.c
    ../../../../../Drivers/BSP/Components/lis2dw12/: lis2dw12_reg.c lis2dw12.c
    ../../../../../Drivers/BSP/Components/lis2mdl/: lis2mdl_reg.c lis2mdl.c
    ../../../../../Drivers/BSP/Components/hts221/: hts221_reg.c hts221.c
    ../../../../../Drivers/BSP/Components/lps22hh/: lps22hh_reg.c lps22hh.c
    ../../../../../Drivers/BSP/Components/stts751/: stts751_reg.c stts751.c
    ../../../../../Drivers/BSP/Components/S2LP/: s2lp.c
    ../../../../../Drivers/BSP/Components/S2LP/S2LP_Library/src/: S2LP_Commands.c S2LP_Csma.c S2LP_Fifo.c S2LP_General.c S2LP_Gpio.c S2LP_PacketHandler.c S2LP_PktBasic.c S2LP_PktStack.c S2LP_PktWMbus.c S2LP_Qi.c S2LP_Radio.c S2LP_Timer.c S2LP_Timer_ex.c S2LP_Types.c
  group Drivers/BSP/GNSS1A1
    ../../../../../Drivers/BSP/GNSS1A1/: gnss1a1_gnss.c
  group Drivers/BSP/IKS01A3
    ../../../../../Drivers/BSP/IKS01A3/: iks01a3_motion_sensors.c iks01a3_motion_sensors_ex.c iks01a3_env_sensors.c iks01a3_env_sensors_ex.c
  group Drivers/BSP/S2868A1
    ../../../../../Drivers/BSP/S2868A1/: s2868a1.c
  group Drivers/STM32L0xx_HAL_Driver
    ../../../../../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal_spi.c stm32l0xx_hal.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_gpio.c stm32l0xx_hal_dma.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_cortex.c stm32l0xx_hal_exti.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal_rtc.c stm32l0xx_hal_rtc_ex.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32l0xx.c
  group Middlewares/lib_gnss/Data Exchange/lib_gnss/LibGNSS
    ../../../../../Middlewares/ST/lib_gnss/LibGNSS/Src/: gnss_parser.c gnss_data.c
  group Middlewares/lib_gnss/Data Exchange/lib_gnss/LibNMEA
    ../../../../../Middlewares/ST/lib_gnss/LibNMEA/Src/: NMEA_parser.c
  group Middlewares/X-CUBE-SFXS2LP1/Network/Sigfox/sigfox_st_library
    ../../../../../Middlewares/Third_Party/Sigfox/Sigfox_STM32_Library/Lib/Monarch/: ST_MONARCH_LIB_CM0+_IAR.a
    ../../../../../Middlewares/Third_Party/Sigfox/Sigfox_STM32_Library/Lib/Retriever/: ST_RETRIEVER_LIB_CM0+_IAR.a
    ../../../../../Middlewares/Third_Party/Sigfox/Sigfox_STM32_Library/Src/: mcu_api.c nvm_api.c rf_api.c
  group Middlewares/X-CUBE-SFXS2LP1/Network/Sigfox/sigfox_library
    ../../../../../Middlewares/Third_Party/Sigfox/Sigfox/Lib/RF_Library/: ADDON_RF_PROTOCOL_MON_CM0+_IAR.a
    ../../../../../Middlewares/Third_Party/Sigfox/Sigfox/Lib/Sigfox_Library/: SFX_LIB_MON_CM0+_IAR.a
  group Middlewares/BlueNRG-MS/Wireless/BlueNRG-MS/Utils
    ../../../../../Middlewares/ST/BlueNRG-MS/utils/: ble_list.c
  group Middlewares/BlueNRG-MS/Wireless/BlueNRG-MS/Controller
    ../../../../../Middlewares/ST/BlueNRG-MS/hci/controller/: bluenrg_gap_aci.c bluenrg_gatt_aci.c bluenrg_hal_aci.c bluenrg_l2cap_aci.c bluenrg_updater_aci.c bluenrg_utils_small.c
  group Middlewares/BlueNRG-MS/Wireless/BlueNRG-MS/HCI_TL/Basic
    ../../../../../Middlewares/ST/BlueNRG-MS/hci/hci_tl_patterns/Basic/: hci_tl.c
    ../../../../../Middlewares/ST/BlueNRG-MS/hci/: hci_le.c
  group Middlewares/X-CUBE-SUBG2/Documentation
    ../../../../../Drivers/BSP/S2868A1/: readme.txt
