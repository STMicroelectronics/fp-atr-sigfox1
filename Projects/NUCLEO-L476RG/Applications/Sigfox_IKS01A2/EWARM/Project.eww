<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Sigfox_IKS01A2.ewp</path>
  </project>
  <batchBuild />
</workspace>
